* gnetlist -o analogue_filter_adc_frontend.ngspice.cir -g spice-sdb analogue_filter_adc_frontend.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
V3 3 0 DC 3V3
V2 5 0 DC 1V65
C2 5 4 14p
R3 2 4 100K
C1 2 1 1u
R2 2 0 100K
R1 3 2 750K
V1 1 0 dc 0 ac 1
.end
